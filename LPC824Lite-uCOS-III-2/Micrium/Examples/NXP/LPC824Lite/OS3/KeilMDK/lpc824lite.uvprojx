# Keil uVision project lpc824lite.uvprojx, settings and files
target LPC824Lite (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc824lite
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\OS3;..\..\BSP;..\..\BSP\KeilMDK;..\..\BSP\OS\uCOS-III;..\..\BSP\NXP\common\chip;..\..\BSP\NXP\common\board;..\..\..\..\..\Software\uC-CPU;..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M0\RealView;..\..\..\..\..\Software\uC-LIB;..\..\..\..\..\Software\uCOS-III\Source;..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M0\Generic\RealView
  asm misc: --cpreproc
  asm include: ..\..\OS3
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group APP
    ../: app.c os_app_hooks.c
  group BSP
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/: cpu_bsp.c bsp.c bsp_int.c bsp_ser.c bsp_i2c.c bsp_at24.c
    ../../BSP/OS/uCOS-III/: bsp_os.c
  group LPC8xx Common
    ../../BSP/NXP/common/chip/: clock_8xx.c ioswm_8xx.c syscon_8xx.c sysinit_8xx.c
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c
    ../../../../../Software/uC-CPU/ARM-Cortex-M0/RealView/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III Source
    ../../../../../Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu_a.s os_cpu_c.c
software components: CMSIS:CORE 4.3.0
